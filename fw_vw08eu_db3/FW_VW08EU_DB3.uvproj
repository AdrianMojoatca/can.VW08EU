# Keil uVision project FW_VW08EU_DB3.uvproj, settings and files
target FW_VW08EU_DB3 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: fw_db3_release +hex
  BeforeMake: c:\cygwin\bin\perl.exe .\build\scripts\pre-build.pl 403
  BeforeMake: powershell.exe -ExecutionPolicy Bypass -File .\build\scripts\check_noncore_core_boundary.ps1
  AfterMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File .\build\scripts\post_build_split_and_enc.ps1 -InputHex .\build\fw_db3_build\fw_db3_release.hex -OutputDir .\build\fw_db3_build -StableEncName fw_db3_release.fw.enc -EncSource fw -Platform DBALL3
  c flags: Optim=4 OneElfS=1
  c define: FW_DB3_BUILD, FW_THIN_SLICE1
  c include: ../VEHICLE_SPECIFIC/lib.config.db3/com.inc.config.fw;../VEHICLE_SPECIFIC/com.lib.detect;../VEHICLE_SPECIFIC/com.lib.func;../VEHICLE_SPECIFIC/com.lib.clutch;../VEHICLE_SPECIFIC/com.lib.sense;../VEHICLE_SPECIFIC/com.lib.scan_new;../VEHICLE_SPECIFIC/com.lib.vw06_scan;../VEHICLE_SPECIFIC/com.lib.scan;../VEHICLE_SPECIFIC/com.lib.scan_manager;./external/can.sdk.db3/APP/features/dball3/lib.about;./external/can.sdk.db3/APP/features/dball3/lib.display;./external/can.sdk.db3/APP/features/dball3/lib.rsr;./external/can.sdk.db3/APP/features/dball3/lib.rsr_feature;./external/can.sdk.db3/APP/features/dball3/lib.rxt;./external/can.sdk.db3/APP/features/dball3/lib.w2w;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.can.per;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.can.sync;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.can.usr;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.dl;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.hazard;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.key_wrap;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.led.detect;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.light.format;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.nvfs.log;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.obd_can;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.pipe;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.process;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.sense_rs_can;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.timeout_q;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.tr;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.tsk.rs;./external/can.sdk.db3/APP/framework/lib.core;./external/can.sdk.db3/APP/framework/lib.status_system;./external/can.sdk.db3/APP/services/control/lib.cmd;./external/can.sdk.db3/APP/services/control/lib.ctl.dl;./external/can.sdk.db3/APP/services/control/lib.pts_ctl;./external/can.sdk.db3/APP/services/events/lib.sense.notify;./external/can.sdk.db3/APP/services/gpio_iface;./external/can.sdk.db3/APP/services/outputs/lib.led;./external/can.sdk.db3/APP/services/outputs/lib.out;./external/can.sdk.db3/APP/services/outputs/lib.out_fifo;./external/can.sdk.db3/APP/services/outputs/lib.out_q;./external/can.sdk.db3/APP/services/queues/lib.exec;./external/can.sdk.db3/APP/services/queues/lib.fifo;./external/can.sdk.db3/APP/services/queues/lib.q;./external/can.sdk.db3/APP/services/queues/lib.reg.q;./external/can.sdk.db3/APP/services/sensors/lib.tach;./external/can.sdk.db3/APP/services/status/lib.bus.status;./external/can.sdk.db3/APP/services/status/lib.status;./external/can.sdk.db3/APP/services/status/lib.status.req;./external/can.sdk.db3/APP/services/timing/lib.timeout;./external/can.sdk.db3/APP/services/timing/lib.timeout.f;./external/can.sdk.db3/APP/services/trace/lib.dbg;./external/can.sdk.db3/APP/services/trace/lib.trace;./external/can.sdk.db3/APP/utilities/lib.bitfield;./external/can.sdk.db3/APP/utilities/lib.crc;./external/can.sdk.db3/APP/utilities/lib.eips;./external/can.sdk.db3/APP/utilities/lib.reg;./external/can.sdk.db3/APP/vehicle/diagnostics/com.ext.lib.obd_can;./external/can.sdk.db3/APP/vehicle/diagnostics/lib.vin;./external/can.sdk.db3/APP/vehicle/programming/lib.prog_1700;./external/can.sdk.db3/APP/vehicle/security/com.lib.dst;./external/can.sdk.db3/APP/vehicle/security/com.lib.dst_bus;./external/can.sdk.db3/APP/vehicle/security/com.lib.dstcrypt;./external/can.sdk.db3/APP/vehicle/security/com.lib.key;./external/can.sdk.db3/BSP/bootloader/lib.app.scatter.1766;./external/can.sdk.db3/BSP/mcu/device/lib.device;./external/can.sdk.db3/BSP/mcu/device/lib.hw_ver_code;./external/can.sdk.db3/BSP/mcu/device/lib.system.type;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.device.lpc1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.gpio_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.nvfs_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.os_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.os_1700.machine;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.sys_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.wake_1700;./external/can.sdk.db3/BSP/peripherals/analog/lib.dac;./external/can.sdk.db3/BSP/peripherals/analog/lib.hw.adc;./external/can.sdk.db3/BSP/peripherals/analog/lib.hw.dac;./external/can.sdk.db3/BSP/peripherals/can/com.ext.lib.can;./external/can.sdk.db3/BSP/peripherals/can/com.ext.lib.can.lut.sw;./external/can.sdk.db3/BSP/peripherals/gpio/lib.gpio_pl;./external/can.sdk.db3/BSP/peripherals/gpio/lib.gpio_wake;./external/can.sdk.db3/BSP/peripherals/interrupts/lib.fiq;./external/can.sdk.db3/BSP/peripherals/interrupts/lib.irq.usr_1700;./external/can.sdk.db3/BSP/peripherals/interrupts/lib.isr_1700;./external/can.sdk.db3/BSP/peripherals/serial/lib.sio;./external/can.sdk.db3/BSP/peripherals/serial/lib.sio_uart;./external/can.sdk.db3/BSP/peripherals/timers/lib.tmr;./external/can.sdk.db3/BSP/peripherals/watchdog/lib.wdog;./external/can.sdk.db3/ENTRY/lib.main_1700;./external/can.sdk.db3/ENTRY/lib.task_main;./external/can.sdk.db3/HAL/communication/can/com.ext.lib.can.v;./external/can.sdk.db3/HAL/communication/can/com.ext.lib.can.v.usr;./external/can.sdk.db3/HAL/communication/d2d/lib.d2d;./external/can.sdk.db3/HAL/communication/d2d/lib.d2d.code/full;./external/can.sdk.db3/HAL/communication/d2di/lib.d2di;./external/can.sdk.db3/HAL/communication/d2di/lib.d2di_uart;./external/can.sdk.db3/HAL/communication/rf/lib.rf;./external/can.sdk.db3/HAL/communication/rf/lib.rf_loop;./external/can.sdk.db3/HAL/communication/rf/lib.rftd;./external/can.sdk.db3/HAL/communication/rf/lib.rftd2;./external/can.sdk.db3/HAL/io/lib.idb;./external/can.sdk.db3/HAL/io/lib.ied;./external/can.sdk.db3/HAL/io/lib.led_usr;./external/can.sdk.db3/HAL/os/scheduler/lib.per_exec;./external/can.sdk.db3/HAL/os/scheduler/lib.reset;./external/can.sdk.db3/HAL/os/scheduler/lib.run_safe;./external/can.sdk.db3/HAL/power/wake/lib.wdog_v;./external/can.sdk.db3/HAL/security/lib.secure.lock;./external/can.sdk.db3/HAL/storage/nvfs/lib.nvfs.usr;./external/can.sdk.db3/INC/dball/core/inc.config_1700;./external/can.sdk.db3/INC/falcon/core/db3_dummy;..\VEHICLE_SPECIFIC\lib.config.db3\inc.config.d2d;..\VEHICLE_SPECIFIC\lib.fw.db3\lib.fw;.\external\can.sdk.db3\APP\features\falcon;.\external\can.sdk.db3\BSP\peripherals\interrupts\lib.vic;.\external\can.sdk.db3\INC\dball\inc.config.fw;.\external\can.sdk.db3\CONTRACT_SDK_DB3;.\external\Core_Contract_SDK_DB3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\external\can.sdk.db3\BSP\bootloader\lib.app.scatter.1766\app_fw_db3_thin.sct
  link misc: --diag_remark=6306,6238 --symdefs project.symdef --datacompressor off --entry fw_ram_init
  group lib.fw.db3
    ../VEHICLE_SPECIFIC/lib.fw.db3/lib.fw/: fw.h fw_init.c fw_descriptor.c fw_boot.c
  group com.lib.detect
    ../VEHICLE_SPECIFIC/com.lib.detect/: detect_can_search.c detect_car_search.c detect_ign_search.c detect_init_nvfs.c detect_pgm.c detect_vars.c detect_vin_search.c detect.h detect_private.h
  group com.lib.func
    ../VEHICLE_SPECIFIC/com.lib.func/: func_arm.c func_can_wake.c func_cmd.c func_cmd_init.c func_disarm.c func_domelight.c func_eips.c func_front_wrd.c func_gas_cap.c func_hazard_ctrl.c func_init.c func_light.c func_lock.c func_oem.c func_prc_init.c func_rap.c func_rear_wrd.c func_rs.c func_trunk_release.c func_unlock_all.c func_vars.c func_wru.c func.h func_cfg.h func_private.h
  group com.lib.clutch
    ../VEHICLE_SPECIFIC/com.lib.clutch/: clutch_disable.c clutch_enable.c clutch_fiq.c clutch_init.c clutch_press.c clutch_release.c clutch_update.c clutch_vars.c clutch.h clutch_private.h
  group com.lib.sense
    ../VEHICLE_SPECIFIC/com.lib.sense/: sense.h sense_brake.c sense_locks.c sense_oem.c sense_oem_alarm.c sense_park_neutral.c sense_doors.c sense_handbrake.c sense_hazard.c sense_hood.c sense_ignition.c sense_init.c sense_private.h sense_rpm.c sense_skd.c sense_speed.c sense_trunk.c sense_vars.c sense_windows_pos.c
  group com.lib.scan_new
    ../VEHICLE_SPECIFIC/com.lib.scan_new/: vw06_scan_pgm1_NEW.c vw06_scan_pgm2_NEW.c vw06_scan_NEW.h
  group com.lib.vw06_scan
    ../VEHICLE_SPECIFIC/com.lib.vw06_scan/: vw06_scan_pgm.c vw06_scan_vars.c vw06_scan.h vw06_scan_private.h
  group com.lib.scan
    ../VEHICLE_SPECIFIC/com.lib.scan/: scan_atomic.c scan_can_rx.c scan_can_tx.c scan_close.c scan_init.c scan_open.c scan_power.c scan_send.c scan_tick.c scan_vars.c scan.h scan_private.h
  group com.lib.scan_manager
    ../VEHICLE_SPECIFIC/com.lib.scan_manager/: scan_car_computer_send.c scan_car_computer_set_state.c scan_car_computer_state_cf_pending.c scan_car_computer_state_handler.c scan_car_computer_state_wait_hw_ack.c scan_car_computer_state_wait_hw_answer.c scan_car_computer_tx_ack.c scan_car_computer_tx_cf_first.c scan_car_computer_tx_cf_next.c scan_car_computer_tx_cs.c scan_car_computer_tx_sf.c scan_manager_can_event.c scan_manager_get_car_computer.c scan_manager_init.c scan_manager_power_off.c scan_manager_power_on.c scan_manager_queue.c scan_manager_release_car_computer.c scan_manager_tick.c scan_manager_tick_power.c scan_manager_tick_state.c scan_manager_trace.c scan_manager_tx_stc.c scan_manager_vars.c scan_manager.h scan_manager_private.h
  group com.Core_Contract_SDK_DB3
    ./external/Core_Contract_SDK_DB3/: core_contract_db3_can_config.c core_contract_db3_can_config.h core_contract_db3_firmware_config.c core_contract_db3_firmware_config.h core_contract_db3_config_ptrs_fw.c core_contract_db3_gpio_iface_shim.c core_contract_db3_integration_example.h core_contract_db3_pts_ctl_config.c core_contract_db3_pts_ctl_config.h core_contract_db3_status_config.c core_contract_db3_status_config.h core_contract_db3_prog_config.c core_contract_db3_prog_config.h
