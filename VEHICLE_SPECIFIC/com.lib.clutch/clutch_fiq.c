/*<#======================================================================#>*/
/*                          FILE HEADER GOES HERE                           */
/*<#======================================================================#>*/

/*==========================================================================*/
// $Id: func_wru.c 1612 2010-09-03 17:10:27Z florin.olariu $
/*==========================================================================*/

/*==========================================================================*/
/*                             I N C L U D E S                              */
/*==========================================================================*/

#include "clutch_private.h"

/*==========================================================================*/
/*      D E F I N E S  -  E N U M E R A T I O N S  -  T Y P E D E F S       */
/*==========================================================================*/

/*==========================================================================*/
/*                  F U N C T I O N   P R O T O T Y P E S                   */
/*==========================================================================*/

/*==========================================================================*/
/*                            V A R I A B L E S                             */
/*==========================================================================*/

/*==========================================================================*/
/*                 F U N C T I O N   D E F I N I T I O N S                  */
/*==========================================================================*/

//--------------------------------------------------------------------------//

void  clutch_fiq( void )
{
    if( tmr_int_sta( clutch_tmr ) )
    {
        if( clutch_on )
        {        
            if( clutch_active )
			{
				CLUTCH_PWM_OUT( FALSE ) ; //release the clutch 
			}
        
            tmr_dis(clutch_tmr ) ;

            tmr_update( clutch_tmr , clutch_value , TRUE ) ; 
        
            tmr_ena( clutch_tmr ) ; 
            
            clutch_on = FALSE ;            
         }
         else
         {   
             if( clutch_active )
			 {
			 	CLUTCH_PWM_OUT( TRUE );
			 }
            
             tmr_dis(clutch_tmr ) ;

             tmr_update( clutch_tmr , CLUTCH_PWM_PERIOD - clutch_value , TRUE ) ; 
            
             tmr_ena( clutch_tmr ) ;    
            
             clutch_on = TRUE ; 
         }
         
    }     
}
    
//--------------------------------------------------------------------------//

    

