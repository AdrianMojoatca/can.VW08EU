/*<#======================================================================#>*/
/*                          FILE HEADER GOES HERE                           */
/*<#======================================================================#>*/

/*==========================================================================*/
// $Id: detect_ign_search.c 2134 2010-12-30 13:26:45Z florin.olariu $
/*==========================================================================*/

/*==========================================================================*/
/*                             I N C L U D E S                              */
/*==========================================================================*/
#include "detect_private.h"
/*==========================================================================*/
/*      D E F I N E S  -  E N U M E R A T I O N S  -  T Y P E D E F S       */
/*==========================================================================*/

/*==========================================================================*/
/*                  F U N C T I O N   P R O T O T Y P E S                   */
/*==========================================================================*/
void ignition_search_can( Can_Msg *can_msg );
/*==========================================================================*/
/*                            V A R I A B L E S                             */
/*==========================================================================*/

/*==========================================================================*/
/*                 F U N C T I O N   D E F I N I T I O N S                  */
/*==========================================================================*/

//--------------------------------------------------------------------------//

Boolean detect_ign_search( void )
{	    
    os_evt_clr( detect_evt , 0xFFFF );
    
    /* PORTARE VW08EU: era CAN_DEV_1 hardcodat (ADI, 1_04, 04_04_2018 - "use HS
       for senses"), ocolind aliasul. Valoarea era aceeasi, dar aliasul urmeaza
       acum comutatorul de canal din detect.h. */
    can_usr_rx_reg_fast( CAN_DEV_DET_IGN , (Reg_Func)ignition_search_can );
    //can_usr_rx_reg_fast( CAN_DEV_DET_IGN , (Reg_Func)ignition_search_can ); 
                
    return os_evt_wait( detect_evt , IGN_OK , 0 , SEARCH_TIMEOUT ) ;     
}


//--------------------------------------------------------------------------//

void ignition_search_can( Can_Msg *can_msg )
{
    static Boolean do_signal = TRUE ; 
    
    switch( can_msg->id )
    {        
        case 0x3C0 :
        {
            if( !!(can_msg->data._8_[2]&0x02) )
            {
                if( do_signal )
                {
                    os_evt_signal( detect_evt , IGN_OK ) ; 

                    do_signal = FALSE ;
                }
            }
        }
        break ; 

        default : break ;
    }
}

//--------------------------------------------------------------------------//


