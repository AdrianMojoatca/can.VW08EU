/*<#======================================================================#>*/
/*                          FILE HEADER GOES HERE                           */
/*<#======================================================================#>*/

/*==========================================================================*/
// $Id: detect_init_nvfs.c 4241 2012-10-25 18:16:25Z florin.olariu $
/*==========================================================================*/

/*==========================================================================*/
/*                             I N C L U D E S                              */
/*==========================================================================*/
#include "detect_private.h"
/*==========================================================================*/
/*      D E F I N E S  -  E N U M E R A T I O N S  -  T Y P E D E F S       */
/*==========================================================================*/

/*==========================================================================*/
/*                  F U N C T I O N   P R O T O T Y P E S                   */
/*==========================================================================*/

/*==========================================================================*/
/*                            V A R I A B L E S                             */
/*==========================================================================*/

/*==========================================================================*/
/*                 F U N C T I O N   D E F I N I T I O N S                  */
/*==========================================================================*/

//--------------------------------------------------------------------------//

Boolean detect_init_nvfs( void )
{
    /* PORTARE VW08EU: era car.bits.can1_detected hardcodat. Poarta trebuie sa
       urmeze canalul vehiculului, altfel pe DS4 (VEHICLE_ON_CAN_DEV_0 == 1)
       nu s-ar ajunge niciodata la [CAR_FOUND] si detectia s-ar relua la fiecare
       pornire. Vezi comutatorul din detect.h. */
    if( (nvfs_rd( nvfs_fw_data , &car) == NVFS_OK) &&  (VEHICLE_CAN_DETECTED) && (car.bits.car==GOLF7) ) 
    {
        TRACE("\n\r[CAR_FOUND]\n\r");

        led_detect_done();
                
        return TRUE ; 
    }
                    
    TRACE("\n\r[CAR_NOT_FOUND]\n\r");

    if( nvfs_wr_create( nvfs_fw_data , &car , sizeof( car )) == NVFS_OK  )
    {                        
        if( nvfs_wr( nvfs_fw_data , &car ) == NVFS_OK )
        {                        
            nvram_usr_commit() ;             
        }        
    }
    
    return FALSE ;
}

//--------------------------------------------------------------------------//

void detect_reset_init( void )
{
    reset_register( (Reset_Func)detect_nvfs_reset );     
}

//--------------------------------------------------------------------------//

void detect_nvfs_reset( void )
{
    nvfs_delete( nvfs_fw_data ) ; 

    nvram_usr_commit() ; 
}

//--------------------------------------------------------------------------//
