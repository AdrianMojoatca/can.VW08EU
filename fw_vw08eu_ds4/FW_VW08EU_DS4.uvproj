# Keil uVision project FW_VW08EU_DS4.uvproj, settings and files
target FW_VW08EU_DS4 (ARM-ADS)
  device: LPC1765 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: fw_ds4_release +hex
  AfterMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File .\build\scripts\post_build_split_and_enc.ps1 -InputHex .\build\fw_ds4_build\fw_ds4_release.hex -OutputDir .\build\fw_ds4_build -StableEncName fw_ds4_release.fw.enc -EncSource fw -Platform NGMM
  c flags: OneElfS=1
  c define: CM800_DEI_BRAND=1 PLATFORM_933 LIB_DL_ENABLE=1 FW_DS4_BUILD
  c include: .\external\can.sdk.ds4\APP\features\falcon;external\can.sdk.ds4\APP\features\dei\lib.dei_core;external\can.sdk.ds4\APP\features\dei\lib.dei_rs;external\can.sdk.ds4\APP\features\dei\lib.dei_scpp;external\can.sdk.ds4\APP\features\dei\lib.dei_ss;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.can.per;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.can.sync;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.can.usr;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.dl;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.hazard;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.key_wrap;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.led.detect;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.light.format;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.nvfs.log;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.obd_can;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.pipe;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.process;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.sense_rs_can;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.timeout_q;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.tr;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.tsk.rs;external\can.sdk.ds4\APP\features\general\lib.about;external\can.sdk.ds4\APP\features\general\lib.brand;external\can.sdk.ds4\APP\features\general\lib.display;external\can.sdk.ds4\APP\features\general\lib.feature;external\can.sdk.ds4\APP\features\ngmm\lib.ngmm_feature;external\can.sdk.ds4\APP\framework\lib.status_system;external\can.sdk.ds4\APP\framework\lib.system;external\can.sdk.ds4\APP\framework\lib.system_ui;external\can.sdk.ds4\APP\services\control\lib.cmd;external\can.sdk.ds4\APP\services\control\lib.ctl.dl;external\can.sdk.ds4\APP\services\control\lib.pts_ctl;external\can.sdk.ds4\APP\services\events\lib.evt;external\can.sdk.ds4\APP\services\events\lib.notify;external\can.sdk.ds4\APP\services\events\lib.sense.notify;external\can.sdk.ds4\APP\services\outputs\lib.led;external\can.sdk.ds4\APP\services\outputs\lib.out;external\can.sdk.ds4\APP\services\outputs\lib.out_fifo;external\can.sdk.ds4\APP\services\outputs\lib.out_q;external\can.sdk.ds4\APP\services\outputs\lib.siren;external\can.sdk.ds4\APP\services\queues\lib.exec;external\can.sdk.ds4\APP\services\queues\lib.fifo;external\can.sdk.ds4\APP\services\queues\lib.q;external\can.sdk.ds4\APP\services\queues\lib.reg.q;external\can.sdk.ds4\APP\services\sensors\lib.ecm_vtacho;external\can.sdk.ds4\APP\services\sensors\lib.sense_rs;external\can.sdk.ds4\APP\services\sensors\lib.sensor;external\can.sdk.ds4\APP\services\sensors\lib.sensor_proto;external\can.sdk.ds4\APP\services\sensors\lib.speed;external\can.sdk.ds4\APP\services\sensors\lib.tacho;external\can.sdk.ds4\APP\services\sensors\lib.temperature;external\can.sdk.ds4\APP\services\sensors\lib.voltage;external\can.sdk.ds4\APP\services\status\lib.bus.status;external\can.sdk.ds4\APP\services\status\lib.status;external\can.sdk.ds4\APP\services\status\lib.status.req;external\can.sdk.ds4\APP\services\timing\lib.sync_count;external\can.sdk.ds4\APP\services\timing\lib.timeout;external\can.sdk.ds4\APP\services\timing\lib.timeout.f;external\can.sdk.ds4\APP\services\trace\lib.dbgcli;external\can.sdk.ds4\APP\utilities\lib.bitfield;external\can.sdk.ds4\APP\utilities\lib.crc;external\can.sdk.ds4\APP\utilities\lib.eips;external\can.sdk.ds4\APP\utilities\lib.npc;external\can.sdk.ds4\APP\utilities\lib.prk;external\can.sdk.ds4\APP\utilities\lib.reg;external\can.sdk.ds4\APP\vehicle\diagnostics\com.ext.lib.obd_can;external\can.sdk.ds4\APP\vehicle\diagnostics\lib.vin;external\can.sdk.ds4\APP\vehicle\programming\lib.prg;external\can.sdk.ds4\APP\vehicle\programming\lib.prg_out;external\can.sdk.ds4\APP\vehicle\security\com.lib.dst;external\can.sdk.ds4\APP\vehicle\security\com.lib.dst_bus;external\can.sdk.ds4\APP\vehicle\security\com.lib.dstcrypt;external\can.sdk.ds4\APP\vehicle\security\com.lib.key;external\can.sdk.ds4\APP\vehicle\security\lib.fob.ctrl.dei;external\can.sdk.ds4\BSP\bootloader\lib.app.scatter.1766;external\can.sdk.ds4\BSP\mcu\device\lib.device;external\can.sdk.ds4\BSP\mcu\device\lib.hw_ver_code;external\can.sdk.ds4\BSP\mcu\device\lib.system.type;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.dei_led_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.dei_out_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.device.lpc1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.fob_ctrl_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.nvfs_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.os_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.os_1700.machine;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.prog_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.sys_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.wake_1700;external\can.sdk.ds4\BSP\peripherals\analog\com.lib.hw.dac;external\can.sdk.ds4\BSP\peripherals\analog\lib.adc;external\can.sdk.ds4\BSP\peripherals\analog\lib.dac;external\can.sdk.ds4\BSP\peripherals\can\com.ext.lib.can;external\can.sdk.ds4\BSP\peripherals\can\com.ext.lib.can.lut.sw;external\can.sdk.ds4\BSP\peripherals\gpio\lib.800_gpio_1700;external\can.sdk.ds4\BSP\peripherals\gpio\lib.gpio_pl;external\can.sdk.ds4\BSP\peripherals\gpio\lib.gpio_wake;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.fiq;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.irq.usr_1700;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.isr_1700;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.vic;external\can.sdk.ds4\BSP\peripherals\serial\lib.sio;external\can.sdk.ds4\BSP\peripherals\serial\lib.sio_uart;external\can.sdk.ds4\BSP\peripherals\timers\lib.rtc;external\can.sdk.ds4\BSP\peripherals\timers\lib.tmr;external\can.sdk.ds4\BSP\peripherals\timers\lib.tmr.irq;external\can.sdk.ds4\BSP\peripherals\timers\lib.vrtc;external\can.sdk.ds4\BSP\peripherals\timers\lib.vrtc.f;external\can.sdk.ds4\BSP\peripherals\watchdog\lib.wdog;external\can.sdk.ds4\ENTRY\lib.main_1700;external\can.sdk.ds4\HAL\communication\can\com.ext.lib.can.v;external\can.sdk.ds4\HAL\communication\can\com.ext.lib.can.v.usr;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d.code\full;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d1_port;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d2_port;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d_switch;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d_valet;external\can.sdk.ds4\HAL\communication\d2d\lib.intl_port;external\can.sdk.ds4\HAL\communication\rf\lib.keeloq;external\can.sdk.ds4\HAL\communication\rf\lib.rf;external\can.sdk.ds4\HAL\communication\rf\lib.rf_loop;external\can.sdk.ds4\HAL\communication\rf\lib.rftd;external\can.sdk.ds4\HAL\communication\rf\lib.rftd2;external\can.sdk.ds4\HAL\io\lib.idb;external\can.sdk.ds4\HAL\io\lib.ied;external\can.sdk.ds4\HAL\io\lib.led_usr;external\can.sdk.ds4\HAL\os\scheduler\lib.per_exec;external\can.sdk.ds4\HAL\os\scheduler\lib.reset;external\can.sdk.ds4\HAL\os\scheduler\lib.run_safe;external\can.sdk.ds4\HAL\power\wake\lib.wdog_v;external\can.sdk.ds4\HAL\security\lib.aes128;external\can.sdk.ds4\HAL\security\lib.aid_dhp;external\can.sdk.ds4\HAL\security\lib.secure.lock;external\can.sdk.ds4\HAL\storage\nvfs\lib.nvfs.usr;external\can.sdk.ds4\INC\cmall\core\inc.config.d2d;external\can.sdk.ds4\INC\cmall\core\inc.core_version;external\can.sdk.ds4\INC\cmall\core\inc.dummy;external\can.sdk.ds4\INC\common\core\inc.comm_core_version;..\VEHICLE_SPECIFIC\com.lib.detect;..\VEHICLE_SPECIFIC\com.lib.func;..\VEHICLE_SPECIFIC\com.lib.sense;..\VEHICLE_SPECIFIC\lib.fw.ds4\lib.fw;..\VEHICLE_SPECIFIC\com.lib.clutch;..\VEHICLE_SPECIFIC\com.lib.scan_new;..\VEHICLE_SPECIFIC\com.lib.vw06_scan;..\VEHICLE_SPECIFIC\com.lib.scan;..\VEHICLE_SPECIFIC\com.lib.scan_manager;..\VEHICLE_SPECIFIC\lib.config.ds4\inc.config_fw;..\VEHICLE_SPECIFIC\lib.config.ds4\com.inc.config.fw;external\can.sdk.ds4\INC\cmall\core\inc.config_1700;.\external\can.sdk.ds4\INC\cmall\inc.config_fw;..\VEHICLE_SPECIFIC\lib.config.ds4\inc.config.d2d;.\external\Core_Contract_SDK_DS4;.\external\can.sdk.ds4\APP\services\gpio_iface
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: external\can.sdk.ds4\BSP\bootloader\lib.app.scatter.1766\app_fw_ds4_thin.sct
  link misc: --diag_remark=6306,6238 --symdefs project.symdef --datacompressor off --entry fw_ram_init
  group com.inc.config.fw
    ../VEHICLE_SPECIFIC/lib.config.ds4/com.inc.config.fw/: config_can.h config_dbg.h config_firmware.h config_gpio.h config_obd_can.h config_prog.h config_pts_ctl.h config_status.h
  group inc.config_fw
    ../VEHICLE_SPECIFIC/lib.config.ds4/inc.config_fw/: config_dei_feature.h config_ngmm_feature.h
  group com.Core_Contract_SDK_DS4
    external/Core_Contract_SDK_DS4/: core_contract_ds4_gpio_iface_shim.c core_contract_ds4_config_ptrs_fw.c core_contract_ds4_firmware_config.c core_contract_ds4_pts_ctl_config.c
  group lib.fw.ds4
    ../VEHICLE_SPECIFIC/lib.fw.ds4/lib.fw/: fw.h fw_init.c fw_descriptor.c fw_boot.c
  group com.lib.detect
    ../VEHICLE_SPECIFIC/com.lib.detect/: detect_can_search.c detect_car_search.c detect_ign_search.c detect_init_nvfs.c detect_pgm.c detect_vars.c detect_vin_search.c detect.h detect_private.h
  group com.lib.func
    ../VEHICLE_SPECIFIC/com.lib.func/: func_arm.c func_can_wake.c func_cmd.c func_cmd_init.c func_disarm.c func_domelight.c func_eips.c func_front_wrd.c func_gas_cap.c func_hazard_ctrl.c func_init.c func_light.c func_lock.c func_oem.c func_prc_init.c func_rap.c func_rear_wrd.c func_rs.c func_trunk_release.c func_unlock_all.c func_vars.c func_wru.c func.h func_cfg.h func_private.h
  group com.lib.clutch
    ../VEHICLE_SPECIFIC/com.lib.clutch/: clutch_disable.c clutch_enable.c clutch_fiq.c clutch_init.c clutch_press.c clutch_release.c clutch_update.c clutch_vars.c clutch.h clutch_private.h
  group com.lib.sense
    ../VEHICLE_SPECIFIC/com.lib.sense/: sense.h sense_brake.c sense_locks.c sense_oem.c sense_oem_alarm.c sense_park_neutral.c sense_doors.c sense_handbrake.c sense_hazard.c sense_hood.c sense_ignition.c sense_init.c sense_private.h sense_rpm.c sense_skd.c sense_speed.c sense_trunk.c sense_vars.c sense_windows_pos.c
  group com.lib.scan_new
    ../VEHICLE_SPECIFIC/com.lib.scan_new/: vw06_scan_pgm1_NEW.c vw06_scan_pgm2_NEW.c vw06_scan_NEW.h
  group com.lib.vw06_scan
    ../VEHICLE_SPECIFIC/com.lib.vw06_scan/: vw06_scan_pgm.c vw06_scan_vars.c vw06_scan.h vw06_scan_private.h
  group com.lib.scan
    ../VEHICLE_SPECIFIC/com.lib.scan/: scan_atomic.c scan_can_rx.c scan_can_tx.c scan_close.c scan_init.c scan_open.c scan_power.c scan_send.c scan_tick.c scan_vars.c scan.h scan_private.h
  group com.lib.scan_manager
    ../VEHICLE_SPECIFIC/com.lib.scan_manager/: scan_car_computer_send.c scan_car_computer_set_state.c scan_car_computer_state_cf_pending.c scan_car_computer_state_handler.c scan_car_computer_state_wait_hw_ack.c scan_car_computer_state_wait_hw_answer.c scan_car_computer_tx_ack.c scan_car_computer_tx_cf_first.c scan_car_computer_tx_cf_next.c scan_car_computer_tx_cs.c scan_car_computer_tx_sf.c scan_manager_can_event.c scan_manager_get_car_computer.c scan_manager_init.c scan_manager_power_off.c scan_manager_power_on.c scan_manager_queue.c scan_manager_release_car_computer.c scan_manager_tick.c scan_manager_tick_power.c scan_manager_tick_state.c scan_manager_trace.c scan_manager_tx_stc.c scan_manager_vars.c scan_manager.h scan_manager_private.h
